# Keil uVision project 药品检测系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS89C51 ISSI
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(11059200)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c hx711.c DHT11.c esp8266.c usart.c delay.c
